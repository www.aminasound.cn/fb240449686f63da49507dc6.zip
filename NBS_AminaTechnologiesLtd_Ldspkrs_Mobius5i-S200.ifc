Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-08-25T09:28:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.4.0.0 - Alternate UI 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Tue Aug 25 09:28:04 2020* Host: NCL-PI04* Database: C:\Users\BocianP\AppData\Local\Temp\{3A70605C-7B03-45D9-B082-C9A71AB43403}\ifc* Database version: 5507* Database creation date: Tue Aug 25 09:27:51 2020* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Tue Aug 25 09:28:04 2020* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Tue Aug 25 09:28:04 2020* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcBuildingElementProxy: Mobius5i-S200, NBS_AminaTechnologiesLtd_Ldspkrs_Mobius5i-S200:Mobius5i-S200:307560
In: Level 0
Type - PredefinedType: USERDEFINED; Classification: Pr_70_75_06_50 (Uniclass2015); Material: NBS_Concept
Type - BOS_General - Author: NBS; BIMObjectName: NBS_AminaTechnologiesLtd_Loudspeakers_Mobius5i-S200; ManufacturerName: Amina Technologies Ltd; ManufacturerURL: https:/​/​uk.aminasound.com/​; NBSCertification: www.nationalbimlibrary.com/cert/dhnogqt1; NBSDescription: Loudspeakers; NBSReference: 90-70-10/435; ProductInformation: https://uk.aminasound.com/file-directory/product/loudspeakers/mobius/datasheet/Mobius5iS200_Datasheet.pdf; Revision: n/a; Uniclass2015Title: Loudspeakers; Uniclass2015Code: Pr_70_75_06_50; Uniclass2015Version: Products v1.18; Version: 1
Type - NBS_Data - LoudspeakerSensitivity: 84dB SPL (at 1m / 2.83Vrms, with 2mm plaster skim); RatedImpedance: 4 ohm; PowerHandlingContinuous: 50W RMS (100W peak); Dispersion: 180° x 180° at specified frequency range; EnclosureFormat: Integrated; CableConnectionsType: Blue butt-splice crimp terminals; CableConnectionsCapacity: 14–16 AWG; Weight: 1.1 kg; EnclosureIngressProtectionMinimum: Sealed away from room with 2mm of covering material and decorative layer; FixingRequirements: Backbox CV/SW200 or Mounting Blocks; InLineProtectionUnit: APUi50C_2, APU-RS8iC or APU-RS16iC; UseableFrequencyRange: 65Hz – 32kHz (±10 dB)
Type - Pset_AudioVisualApplianceTypeCommon - AudioVolume: n/a; MediaSource: n/a; Reference: n/a
Type - Pset_AudioVisualApplianceTypeSpeaker - FrequencyResponse: 90Hz – 30kHz (-6 dB); Impedence: 4 ohm; SpeakerDriverSize: n/a; SpeakerMounting: WALL; SpeakerType: FULLRANGE
Type - IFC - IfcExportAs: IfcAudioVisualApplianceType; IfcExportType: SPEAKER
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_70_75_06_50:Loudspeakers; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Slimline fully-covered loudspeaker providing a slimline alternative to the Mobius5i invisible loudspeaker, for use when there is limited stud/ joist spacing or for use in curved walls/ ceilings with a radius greater than 5 m; DurationUnit: year; ExpectedLife: n/a; Features: Suitable for both commercial and residential applications, fully covered with 2 mm of almost any finishing material including wood, plaster, stone laminates, leather and more, completely invisible in application, exceptional dispersion, typically requiring two to four times fewer loudspeakers to cover the same space when compared to paper-cone based loudspeakers, beneficial in acoustically harsh spaces; Finish: n/a; Grade: n/a; Manufacturer: sales@aminasound.com; Material: n/a; ModelNumber: Mobius5i-S200; ModelReference: Mobius; Name: Loudspeakers_Mobius5i-S200_AminaTechnologiesLtd; NominalHeight: 450 mm; NominalLength: 200 mm; NominalWidth: 32 mm; ReplacementCost: n/a; Shape: Rectangular; Size: 450 x 200 x 32 mm; SustainabilityPerformance: n/a; WarrantyDescription: Manufacturer limited warranty; WarrantyDurationLabor: 0; WarrantyDurationParts: 10; WarrantyDurationUnit: year; WarrantyGuarantorLabor: Installer; WarrantyGuarantorParts: Amina Technologies Ltd
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcDistributionPort, Port_307560
Description: Flow; FlowDirection: SOURCEANDSINK
